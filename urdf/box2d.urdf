Commit message: more osqp stuff

File: urdf/box2d.urdf (robot description, URDF)
Before this commit: robot box2d, 2 links, 1 joints
Links:
- link box: geometry collision sphere radius=0; collision sphere radius=0
